FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI:append = "file://0001-move-gpio-fan-and-regulator-pcie-switch.patch"
